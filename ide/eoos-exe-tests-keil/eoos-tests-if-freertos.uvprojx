# Keil uVision project eoos-tests-if-freertos.uvprojx, settings and files
target eoos-tests (ARM-GNU)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: eoos-tests-if-freertos
  group board
    ../../codebase/board/source/: pcb.Board.cpp
  group cpu
    ../../codebase/cpu/source/: cpu.Boot.gcc.s cpu.InterruptController.gcc.s cpu.Boot.cpp cpu.InterruptController.cpp cpu.NoAllocator.cpp cpu.PllController.cpp cpu.Processor.cpp cpu.TimerController.cpp cpu.InterruptGlobal.cpp cpu.Registers.cpp cpu.RegistersController.cpp
  group driver
    ../../codebase/driver/usart/source/: drv.UsartController.cpp drv.Usart.cpp
    ../../codebase/driver/null/source/: drv.Null.cpp drv.NullController.cpp
    ../../codebase/driver/gpio/source/: drv.Gpio.cpp drv.GpioController.cpp
    ../../codebase/driver/can/source/: drv.Can.cpp drv.CanController.cpp drv.CanResourceTx.cpp drv.CanResourceTxMailbox.cpp drv.CanResourceTxMailboxRoutine.cpp drv.CanResourceRx.cpp drv.CanResourceRxFifoRoutine.cpp
  group kernel
    ../../codebase/kernel/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../codebase/kernel/source/portable/: port.Kernel.cpp
  group system
    ../../codebase/system/source/: sys.Call.cpp sys.Heap.cpp sys.Main.cpp sys.NoAllocator.cpp sys.OutStream.cpp sys.Scheduler.cpp sys.MutexManager.cpp sys.SemaphoreManager.cpp sys.StreamManager.cpp sys.System.cpp sys.ThreadPrimary.cpp sys.SchedulerRoutineSvcall.cpp sys.SchedulerRoutineTimer.cpp sys.Svc.cpp sys.Thread.cpp
  group tests
    ../../codebase/tests/source/: ContexSwitchLowTest.s ContexSwitchTest.cpp ThreadYieldTest.cpp MutexTest.cpp SemaphoreTest.cpp DriverUsartTest.cpp DriverNullTest.cpp DriverGpioTest.cpp DriverCanTest.cpp Program.cpp
