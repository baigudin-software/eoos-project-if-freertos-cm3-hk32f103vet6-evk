# Keil uVision project eoos-if-freertos.uvprojx, settings and files
target eoos (6180000::V6.18::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: eoos
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\..\codebase\drivers\cpu\hk\HK32F103xCxDxE\memory\Memory.HK32F103VET6.keil.sct
  group cpu
    ../../codebase/drivers/cpu/hk/HK32F103xCxDxE/source/: cpu.Boot.keil.s cpu.Interrupt.keil.s
